# Keil uVision project LabaPro.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GY91APP +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output  ./Objects/GY91APP.bin ./Objects/GY91APP.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_XL,USE_STDPERIPH_DRIVER
  c misc: --locale=english
  c include: ..\PROJECT;..\CORE;..\STM32F10x_FWLib\inc;..\USB\USB_CONFIG\inc;..\USB\USB_CORE\inc;..\FATFS;..\UI;..\USER;..\HARDWARE;..\PINYIN;..\QRCode
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group USER
    ../USER/: main.c OpData.c OpFile.c OpPara.c OpTable.c
  group UI
    ../UI/: Config_ui.c KongJian.c ui_Public.c ui_Dialog.c ui_View.c ui_Start.c ui_Main.c ui_Sample10.c ui_Sampset.c ui_Sampdisp.c ui_Condition.c ui_Analyze.c ui_Biaoding.c ui_Gain.c ui_Heat.c ui_SampJGJ.c ui_SampBlock.c ui_Browse10.c ui_Verify.c ui_Paraset10.c
  group AIMLIB
    ../USER/: AimLib.c AimLib.lib
  group HARDWARE
    ../HARDWARE/: ledBeep.c timer.c batAdc.c delay.c power.c key.c lcd.c bkLed.c font.c touch.c systic.c uart.c rx8010.c iwdog.c max17201.c ct1711.c gps.c ft6336u.c hcBT20.c
  group PINYIN
    ../PINYIN/: fontupd.c pyinput.c pytext.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_bkp.c
  group CORE
    ../CORE/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_xl.s
  group FATFS
    ../FATFS/: diskio.c ff.c w25qxx.c malloc.c exfuns.c cc936.c
  group QRCode
    ../QRCode/: qr_encode.c qr_generate.c
  group USB_DRIVER
    ../USB/USB_CORE/src/: usb_sil.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group Mass_Storage
    ../USB/USB_CONFIG/src/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group README
    ../: LOG.TXT
